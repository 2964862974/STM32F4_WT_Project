# Keil uVision project stm32f407.uvprojx, settings and files
target stm32f407 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=25000000
  c include: ..\app;..\app\font;..\app\image;..\app\page;..\driver\cpu_tick;..\driver\console;..\driver\rtc;..\driver\aht20;..\driver\esp_at;..\driver\st7789;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\third_lib\FreeRTOS\include;..\third_lib\FreeRTOS\portable;..\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../app/: main.c board.c loop.c esp32c3.c weather.c FreeRTOSConfig.h
  group app/font
    ../app/font/: font16_maple.c font24_maple_bold.c font24_maple.c font32_maple_bold.c font42_maple.c font54_maple_medium.c font62_maple_bold.c font76_maple_bold.c
  group app/image
    ../app/image/: icon_duoyun.c icon_leizhenyu.c icon_qing.c icon_wenduji.c icon_wifi.c icon_yintian.c icon_yueliang.c icon_zhongxue.c icon_zhongyu.c img_error.c img_meihua.c img_wifi.c
  group app/page
    ../app/page/: error_page.c main_page.c welcome_page.c wifi_page.c
  group driver
    ../driver/console/: console.c
    ../driver/rtc/: rtc.c
    ../driver/aht20/: aht20.c
    ../driver/esp_at/: esp_at.c
    ../driver/st7789/: st7789.c
    ../driver/: delay.c delay.h
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib/FreeRTOS
    ../third_lib/FreeRTOS/portable/: heap_4.c mpu_wrappers.c port.c
    ../third_lib/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
